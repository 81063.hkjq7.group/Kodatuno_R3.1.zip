21,21
100.000000,0.000000,0.000000
100.000000,5.000000,0.000000
100.000000,10.000000,0.000000
100.000000,15.000000,0.000000
100.000000,20.000000,0.000000
100.000000,25.000000,0.000000
100.000000,30.000000,0.000000
100.000000,35.000000,0.000000
100.000000,40.000000,0.000000
100.000000,45.000000,0.000000
100.000000,50.000000,0.000000
100.000000,55.000000,0.000000
100.000000,60.000000,0.000000
100.000000,65.000000,0.000000
100.000000,70.000000,0.000000
100.000000,75.000000,0.000000
100.000000,80.000000,0.000000
100.000000,85.000000,0.000000
100.000000,90.000000,0.000000
100.000000,95.000000,0.000000
100.000000,100.000000,0.000000
95.000000,0.000000,0.000000
95.000217,4.906205,0.247588
94.997592,9.974009,0.018565
94.994930,15.296287,-0.913158
95.000172,20.678950,-1.953493
95.019261,25.960843,-2.613897
95.050172,31.124564,-2.860342
95.088977,36.187101,-2.767541
95.131746,41.165442,-2.410207
95.174549,46.076574,-1.863052
95.213456,50.937486,-1.200791
95.244539,55.765166,-0.498135
95.263867,60.576603,0.170201
95.267511,65.388783,0.729505
95.251541,70.218695,1.105064
95.212028,75.083327,1.222165
95.145042,79.999667,1.006094
95.055445,84.976091,0.465595
94.982600,89.987176,-0.063077
94.973090,94.999550,-0.172547
95.000000,100.000000,0.000000
90.000000,0.000000,0.000000
89.997396,4.970803,0.029750
89.987957,10.388498,-1.239008
89.982470,16.300355,-3.833768
90.000529,22.280386,-6.443793
90.056608,27.978392,-8.003364
90.145029,33.363436,-8.467091
90.255297,38.480964,-8.033696
90.376913,43.376421,-6.901898
90.499381,48.095252,-5.270418
90.612203,52.682904,-3.337977
90.704883,57.184821,-1.303294
90.766924,61.646450,0.634910
90.787827,66.113235,2.277914
90.757096,70.630622,3.426999
90.664235,75.244057,3.883444
90.498745,79.998984,3.448528
90.269688,84.919010,2.116313
90.062875,89.942025,0.637417
89.980814,94.985462,-0.067577
90.000000,100.000000,0.000000
85.000000,0.000000,0.000000
84.991089,5.276772,-0.844030
84.972835,11.257672,-3.682095
84.966904,17.723323,-7.742411
85.000919,24.157830,-11.433575
85.094966,30.143267,-13.482681
85.239900,35.654997,-13.886467
85.419587,40.762473,-12.945427
85.617891,45.535150,-10.960058
85.818676,50.042482,-8.230855
86.005808,54.353922,-5.058313
86.163151,58.538924,-1.742928
86.274569,62.666944,1.414805
86.323927,66.807434,4.114391
86.295090,71.029848,6.055334
86.171922,75.403641,6.937138
85.938288,79.998266,6.459308
85.602058,84.851536,4.570313
85.265310,89.877089,2.195663
85.051787,94.958455,0.490210
85.000000,100.000000,0.000000
80.000000,0.000000,0.000000
79.984058,5.612605,-1.719738
79.957584,12.106407,-5.828366
79.952628,18.964477,-10.747618
80.001253,25.669283,-14.897638
80.126431,31.808209,-17.036566
80.316332,37.370306,-17.216480
80.550798,42.440719,-15.799030
80.809671,47.104593,-13.145862
81.072793,51.447076,-9.618624
81.320006,55.553312,-5.578963
81.531154,59.508448,-1.388529
81.686077,63.397629,2.591033
81.764620,67.306001,5.998073
81.746623,71.318709,8.470944
81.611929,75.520900,9.647999
81.340381,79.997720,9.167590
80.935876,84.797001,6.930581
80.496711,89.820144,3.868049
80.144336,94.932634,1.163734
80.000000,100.000000,0.000000
75.000000,0.000000,0.000000
74.978644,5.802828,-2.060070
74.946679,12.545247,-6.476129
74.943240,19.539850,-11.344168
75.001456,26.306800,-15.254456
75.144766,32.468189,-17.113539
75.359881,38.023518,-17.008227
75.624728,43.062577,-15.307706
75.917233,47.675157,-12.381158
76.215323,51.951050,-8.597769
76.496924,55.980046,-4.326721
76.739962,59.851937,0.062800
76.922363,63.656514,4.201611
77.022054,67.483568,7.720528
77.016962,71.422891,10.250366
76.885011,75.564274,11.421942
76.604129,79.997507,10.866071
76.173772,84.773881,8.457984
75.677891,89.793593,5.032102
75.222614,94.919530,1.667529
75.000000,100.000000,0.000000
70.000000,0.000000,0.000000
69.975271,5.836917,-1.854682
69.940792,12.562723,-5.647705
69.939127,19.456626,-9.641037
70.001525,26.101931,-12.708319
70.149814,32.173224,-13.984571
70.370463,37.675813,-13.567690
70.641481,42.694129,-11.785934
70.940878,47.312601,-8.967566
71.246664,51.615659,-5.440845
71.536848,55.687734,-1.534032
71.789439,59.613255,2.424613
71.982447,63.476653,6.106828
72.093881,67.362357,9.184355
72.101752,71.354798,11.328931
71.984069,75.538405,12.212297
71.718841,79.997610,11.506193
71.301265,84.781082,9.083902
70.793991,89.797161,5.609661
70.278955,94.919402,1.958534
70.000000,100.000000,0.000000
65.000000,0.000000,0.000000
64.973882,5.745865,-1.225854
64.939639,12.242497,-3.673470
64.939868,18.845607,-6.153456
65.001473,25.222008,-7.912965
65.142955,31.113022,-8.379304
65.351613,36.526045,-7.642516
65.607282,41.532128,-5.951201
65.889797,46.202321,-3.553961
66.178991,50.607676,-0.699396
66.454701,54.819243,2.363892
66.696761,58.908074,5.387305
66.885005,62.945220,8.122239
66.999269,67.001730,10.320096
67.019387,71.148657,11.732273
66.925195,75.457052,12.110172
66.696526,79.997965,11.205189
66.324730,84.812579,8.908469
65.846344,89.824866,5.659561
65.312788,94.929674,2.054697
65.000000,100.000000,0.000000
60.000000,0.000000,0.000000
59.974419,5.560664,-0.295865
59.942935,11.668234,-0.883800
59.945040,17.837592,-1.396659
60.001313,23.834362,-1.522133
60.125566,29.477294,-1.027377
60.306865,34.773068,0.019646
60.528354,39.773327,1.479008
60.773177,44.529714,3.210780
61.024481,49.093872,5.075034
61.265408,53.517442,6.931841
61.479106,57.852067,8.641272
61.648717,62.149390,10.063399
61.757386,66.461053,11.058294
61.788260,70.838699,11.486027
61.724482,75.333971,11.206670
61.549196,79.998510,10.080295
61.250546,84.862352,8.031817
60.836282,89.870727,5.240636
60.323543,94.947770,1.973966
60.000000,100.000000,0.000000
55.000000,0.000000,0.000000
54.976824,5.312306,0.813004
54.950397,10.923595,2.390928
54.954220,16.563380,4.114122
55.001056,22.106325,5.810440
55.099024,27.455748,7.341568
55.239751,32.615735,8.671146
55.410919,37.614480,9.787206
55.600210,42.480177,10.677781
55.795308,47.241017,11.330902
55.983894,51.925195,11.734601
56.153650,56.560905,11.876912
56.292258,61.176338,11.745864
56.387402,65.799690,11.329492
56.426762,70.459152,10.615826
56.398022,75.182919,9.592899
56.288863,79.999183,8.248743
56.085090,84.924375,6.554082
55.765136,89.928761,4.411719
55.310648,94.971112,1.734290
55.000000,100.000000,0.000000
50.000000,0.000000,0.000000
49.981040,5.031783,1.978474
49.961739,10.092243,5.820338
49.966988,15.153771,9.863653
50.000717,20.205227,13.431014
50.064706,25.238094,15.997890
50.153804,30.252901,17.564336
50.261201,35.252341,18.255908
50.380086,40.239104,18.198165
50.503649,45.215884,17.516664
50.625081,50.185372,16.336963
50.737571,55.150260,14.784619
50.834309,60.113240,12.985189
50.908484,65.077004,11.064232
50.953287,70.044245,9.147304
50.961908,75.017653,7.359963
50.927537,79.999921,5.827767
50.834739,84.992628,4.575396
50.634239,89.992988,3.231645
50.273533,94.997124,1.353617
50.000000,100.000000,0.000000
45.000000,0.000000,0.000000
44.987008,4.750088,3.078265
44.976677,9.257841,9.074054
44.982921,13.739565,15.336703
45.000308,18.298400,20.685851
45.023991,23.014041,24.211948
45.052560,27.883420,25.951566
45.085424,32.883661,26.167628
45.121994,37.991894,25.123057
45.161681,43.185244,23.080778
45.203894,48.440839,20.303714
45.248045,53.735805,17.054790
45.293544,59.047270,13.596930
45.339802,64.352362,10.193057
45.386228,69.628206,7.106095
45.432233,74.851930,4.598969
45.477229,80.000661,2.934602
45.505871,85.061088,2.195894
45.444923,90.057426,1.759248
45.211628,95.023229,0.849895
45.000000,100.000000,0.000000
40.000000,0.000000,0.000000
39.994671,4.498212,3.990096
39.994926,8.504053,11.821697
40.001596,12.451562,20.018035
39.999841,16.553174,26.921212
39.978257,20.973300,31.254107
39.939552,25.706145,33.085200
39.889814,30.705196,32.804898
39.835130,35.923942,30.803607
39.781585,41.315868,27.471735
39.735267,46.834462,23.199689
39.702262,52.433212,18.377876
39.688656,58.065604,13.396702
39.700537,63.685126,8.646575
39.743991,69.245264,4.517903
39.825104,74.699506,1.401091
39.949963,80.001340,-0.313453
40.104875,85.123731,-0.484234
40.198528,90.116093,0.053403
40.124363,95.046851,0.241091
40.000000,100.000000,0.000000
35.000000,0.000000,0.000000
35.003529,4.307149,4.589514
35.015293,7.914540,13.728418
35.021788,11.420560,23.388464
34.999348,15.136883,31.483446
34.930515,19.305579,36.402764
34.822229,23.919931,38.236833
34.687266,28.913699,37.483033
34.538403,34.220644,34.638739
34.388418,39.774527,30.201331
34.250087,45.509110,24.668185
34.136188,51.358152,18.536680
34.059496,57.255416,12.304192
34.032790,63.134661,6.468100
34.068845,68.929649,1.525781
34.180439,74.574140,-2.025387
34.380349,80.001896,-3.688027
34.657991,85.174536,-3.267178
34.911101,90.163006,-1.754699
35.017393,95.065413,-0.424247
35.000000,100.000000,0.000000
30.000000,0.000000,0.000000
30.011737,4.207889,4.745447
30.033811,7.572966,14.445735
30.039822,10.777360,24.916758
29.998914,14.216856,33.719171
29.888760,18.200588,38.960814
29.719962,22.723631,40.736710
29.510997,27.705922,39.617306
29.280346,33.067397,36.173049
29.046487,38.727994,30.974388
28.827899,44.607649,24.591767
28.643060,50.626299,17.595636
28.510450,56.703881,10.556441
28.448548,62.760331,4.044629
28.475832,68.715588,-1.369353
28.610782,74.489587,-5.115057
28.871875,80.002266,-6.622037
29.251990,85.207478,-5.657449
29.643529,90.192186,-3.313349
29.915331,95.076338,-1.004312
30.000000,100.000000,0.000000
25.000000,0.000000,0.000000
25.017192,4.231426,4.325562
25.045987,7.562993,13.622578
25.051556,10.652761,24.069399
24.998634,13.960424,32.975055
24.861932,17.848036,38.235808
24.654390,22.316100,39.926215
24.398091,27.278619,38.641979
24.115118,32.649597,34.978804
23.827555,38.343038,29.532392
23.557486,44.272946,22.898446
23.326993,50.353323,15.672669
23.158161,56.498174,8.450765
23.073073,62.621502,1.828436
23.093813,68.637311,-3.598615
23.242464,74.459605,-7.234685
23.541109,80.002387,-8.484070
23.985142,85.216537,-7.103015
24.465216,90.197649,-4.228957
24.846395,95.077050,-1.339585
25.000000,100.000000,0.000000
20.000000,0.000000,0.000000
20.017793,4.408752,3.197529
20.047330,7.968284,10.907877
20.052851,11.177563,20.312866
19.998603,14.534920,28.597764
19.858971,18.437633,33.535293
19.647151,22.896191,35.146732
19.385626,27.828544,33.991313
19.096876,33.152641,30.628268
18.803384,38.786433,25.616829
18.527632,44.647868,19.516231
18.292101,50.654897,12.885704
18.119272,56.725470,6.284482
18.031628,62.777537,0.271797
18.051650,68.729047,-4.593119
18.201819,74.497951,-7.751032
18.504619,80.002198,-8.642710
18.955718,85.195689,-7.051847
19.445566,90.173415,-4.107929
19.838803,95.064971,-1.270544
20.000000,100.000000,0.000000
15.000000,0.000000,0.000000
15.012591,4.730770,1.424845
15.035673,8.780501,6.392926
15.041574,12.362776,13.674680
14.998873,15.975833,20.528927
14.884871,20.023256,24.750568
14.710504,24.528759,26.279709
14.494753,29.425176,25.569681
14.256598,34.645342,23.073816
14.015019,40.122091,19.245447
13.788999,45.788255,14.537906
13.597516,51.576670,9.404524
13.459554,57.420168,4.298635
13.394091,63.251584,-0.326430
13.420110,69.003752,-4.017338
13.556590,74.609505,-6.320758
13.822513,80.001678,-6.783357
14.211222,85.143694,-5.257787
14.615452,90.119031,-2.797517
14.904167,95.040271,-0.743179
15.000000,100.000000,0.000000
10.000000,0.000000,0.000000
10.005278,5.026854,-0.139937
10.018226,9.620601,1.951439
10.023692,13.736742,6.442965
9.999320,17.787431,11.107447
9.928736,22.111467,14.125024
9.818918,26.738724,15.382664
9.682433,31.625169,15.175683
9.531847,36.726767,13.799397
9.379725,41.999484,11.549122
9.238633,47.399287,8.720174
9.121137,52.882140,5.607869
9.039803,58.404011,2.507523
9.007197,63.920865,-0.285548
9.035884,69.388668,-2.476028
9.138431,74.763386,-3.768600
9.327403,80.000985,-3.867950
9.594620,85.078585,-2.707128
9.850488,90.056328,-1.115400
9.987189,95.014173,-0.128608
10.000000,100.000000,0.000000
5.000000,0.000000,0.000000
5.000657,5.090425,-0.469788
5.004492,10.024038,-0.134082
5.007207,14.711254,1.449828
4.999774,19.340128,3.276293
4.975495,24.066795,4.514672
4.936866,28.908098,5.093432
4.888583,33.847556,5.122657
4.835344,38.868688,4.712429
4.781845,43.955014,3.972829
4.732783,49.090053,3.013941
4.692856,54.257323,1.945845
4.666759,59.440345,0.878624
4.659190,64.622637,-0.077639
4.674846,69.787717,-0.812862
4.718423,74.919107,-1.216964
4.794618,80.000323,-1.179862
4.898750,85.023239,-0.688412
4.989334,90.012502,-0.109899
5.017002,95.000471,0.103545
5.000000,100.000000,0.000000
0.000000,0.000000,0.000000
0.000000,5.000000,0.000000
0.000000,10.000000,0.000000
0.000000,15.000000,0.000000
0.000000,20.000000,0.000000
0.000000,25.000000,0.000000
0.000000,30.000000,0.000000
0.000000,35.000000,0.000000
0.000000,40.000000,0.000000
0.000000,45.000000,0.000000
0.000000,50.000000,0.000000
0.000000,55.000000,0.000000
0.000000,60.000000,0.000000
0.000000,65.000000,0.000000
0.000000,70.000000,0.000000
0.000000,75.000000,0.000000
0.000000,80.000000,0.000000
0.000000,85.000000,0.000000
0.000000,90.000000,0.000000
0.000000,95.000000,0.000000
0.000000,100.000000,0.000000
