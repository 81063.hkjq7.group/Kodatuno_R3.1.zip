5,7
0,0,0
10,10,0
30,20,0
50,10,0
70,30,0
90,-10,0
100,0,0
0,0,20
10,10,20
40,20,20
50,10,20
70,0,20
90,-10,20
90,0,20
0,0,40
10,10,40
20,20,40
50,10,40
70,30,40
90,-10,40
110,0,40
0,0,60
10,10,60
40,20,60
50,10,60
70,-30,60
90,-10,60
100,0,60
0,0,80
10,10,80
40,20,80
50,10,80
70,20,80
90,-10,80
100,0,80
