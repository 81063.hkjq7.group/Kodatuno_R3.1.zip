0,0,10
1.736481777,0,9.84807753
3.420201433,0,9.396926208
5,0,8.660254038
6.427876097,0,7.660444431
7.660444431,0,6.427876097
8.660254038,0,5
9.396926208,0,3.420201433
9.84807753,0,1.736481777
10,0,0
