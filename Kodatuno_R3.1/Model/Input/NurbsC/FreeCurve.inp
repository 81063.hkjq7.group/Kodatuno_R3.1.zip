0,0,0
10,10,0
20,0,0
30,-10,0
40,0,0
50,10,0
60,0,0
0,0,0
